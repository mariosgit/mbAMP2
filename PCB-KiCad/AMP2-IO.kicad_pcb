# Repository mariosgit/mbAMP2

File README.md:

# mbAMP2

A fully digital audio amplifier.

## Status

Updates towards Version v02
* Removed Pi Header - to much space
* Added 4 extra pins to the FreeDSP header (PowerDown, Fault)
* Added power polarity overvoltage overcurrent protection.
* Added Voltage drop detection for clean/krackless shutdown. (to be tested)

## Todo

* order

## Minimum Startup Code

The chip needs some I2C talking to start up.

You will also need some kind of I2S data source, e.g. Teensy Audio, some china ADC or SPDIF receiver or my AMP2-IO the do it all solution, see below.

```
bool Tas5805m::begin()
{
    Wire.begin();
    write(DEVICE_CTRL_2, 0x02);  // HiZ
    delay(5);
    write(DEVICE_CTRL_2, 0x03);  // Play
}
void Tas5805m::write(byte reg, byte data)
{
    Wire.beginTransmission(_adr);
    Wire.write(reg);
    Wire.write(data);
    byte result = Wire.endTransmission();
    logerror(result, reg);
}
```

[My TAS5805m repo](https://github.com/mariosgit/TAS58xx) contains more examples how to use the thing.

# mbAMP2-IO Board

Input board with Sampe Rate Converter, ADC, SPDIF...

## Status

Not tested, in development.

* works on breadboard.

## Todo

* move to own repo.
* more 3D on the rendering.

## Issues 1.0rc1

* done Fuse solder mask blocker to be wider -> wrong, added rectangles for signals, done.
* done Move 6.5V reg right out of the ribbon caple way, done.
* done: BUG: TORX17x has no power, inductor to ground ??? isn't it a little cracy. And it may use 5V or 3.3.
* done: BUG TORX  output goes through a 10n cap nd 220ohm, at least in a FreeDSP.
* done: Add pull down on S0 S1, ADC on input 0 ? default ? It's flowting as long MCP23009 is of.
* done: BUG!!! Header is flipped !!! haeh Pfusch !!!
* done: BUG: dir9001 cksel must be low !? Or automatic -> connect GND (or error pin)
* done: The relais is bistable switched by turning polarity. I need the none latching ! 769-AGN200S03Z
* wont: Reset Line, Pull up ! is internally high, ok. Stand Alone startup circuit !? No the Controller can do it.
* ...
* BUG?: The 7404 cinch in seeems to oscilate !? Testing !

# License

#### Attribution-NonCommercial-ShareAlike - CC BY-NC-SA

```
Attribution — You must give appropriate credit, provide a link to the license, and indicate if changes were made. You may do so in any reasonable manner, but not in any way that suggests the licensor endorses you or your use.

NonCommercial — You may not use the material for commercial purposes.

ShareAlike — If you remix, transform, or build upon the material, you must distribute your contributions under the same license as the original.

No additional restrictions — You may not apply legal terms or technological measures that legally restrict others from doing anything the license permits.
```
[All the legal blabla here](https://creativecommons.org/licenses/by-nc-sa/4.0/legalcode)

## KiCad design PCB-KiCad/AMP2-IO.kicad_pcb

Parts:
C1, C2: 4.7u; C025_050-055X075
C3, C4, C18, C19, C23: 10u; CT6032; MOUSER 80-T491C106K25AT7280
C5, C6, C7, C11, C13, C15, C20, C21, C24, C25, C26, C27: 100n; C0603
C8, C9, C10, C12, C14: 10u; C1210K; MOUSER 81-GCM32DL81A106KA7L
C16: 4.7n; C0603
C17: 68n; C0603
C22: 10n; C0603
D1, D2: SCHOTTKY-DIODESMD; SMB
D3: MBR0520LT; SOD123; MOUSER 863-MBR130T3G
EXT1, EXT2: FE08-1; FE08
FS1, FS2: LEDSMT1206; 1206
FUSE0: Fuse; L4532M; MOUSER 650-MINIASMDC050F-2
IC1: 7404TS; TSSOP14; MOUSER 595-SN74HC04APWR
IC2: R-78E6.5-0.5; TO220V; MOUSER 919-R-786.5-0.5
IC3: REG1117; SOT223; MOUSER 863-LM1117MPX-50NOPB
IC4: REG1117; SOT223; MOUSER 863-LM1117MPX-33NOPB
JMP1: 0R-JUMPA; A0R-JMP
K2: GN200S03; GN-S; MOUSER 769-AGN200S03Z
L1, L2, L3: 220uH; L4532M; MOUSER 710-7447669220
OX1: TORX173
POWER0: LEDSMT1206; 1206
Q4: 24.576; 7.0X5.0_KXO-82-TCXO; MOUSER 998-1001AI2024.5760T
R1, R2, R22, R23: 4.7k; R0603
R3: 75; R0603
R4, R6, R7, R12, R13, R14, R15, R16, R18, R19, R20: 2.2k; R0603
R5: 680; R0603
R8: 220; R0603
R9, R10, R11: 47; R0603
R17: 47k; R0603
R21: open; R0603
RX_ERROR0: LEDSMT1206; 1206
SJ1, SJ2: SJ
SPDIF0: 736880-49; MOUSER 502-PJRAN1X1U01AUX
SRCUNLOCK0: LEDSMT1206; 1206
SRC_BYPASS0: JP1E; JP1
SV1: FE05-1
SV3: FE08-1; FE08
SV4: FE10-2
TVS0: 26Vbi; SMC; MOUSER 710-824551241
U$1: SRC4192; SSOP28BU; MOUSER 595-SRC4192IDB
U$2: DIR9001; TSSOP28; MOUSER 595-DIR9001PW
U$3: PCM1802; SSOP20DB; MOUSER 595-PCM1802
U$4: MCP23009; SSOP20BU; MOUSER 579-MCP23009T-E/SS
U$5: SN74CBT3253; TSSOP16-PW; MOUSER 595-SN74CBT3253CPW
U$6: SN74CBT3253; TSSOP16-PW
U$7: TORX135X; MOUSER 757-TORX1355VF
X3: MKDSN1,5/2-5,08; MKDSN1,5_2-5,08
XL0: 736880-49
XR0: 736880-49

Connections:
+3V3: C5.1, C7.1, C9.1, C19.+, C21.1, C26.1, C27.1, EXT1.8, EXT2.8, IC1.14 (VCC), IC4.2 (VOUT), JMP1.1, L2.1, Q4.4 (VDD), R7.1, R12.2, R21.1, SRC_BYPASS0.2, U$1.7 (VIO), U$1.10 (IFMT0), U$1.19 (OFMT0), U$1.22 (VDD), U$1.26 (MODE0), U$1.27 (MODE1), U$2.5 (VDD), U$2.25 (FMT0), U$2.26 (FMT1), U$3.7 (PDWN), U$3.14 (VDD), U$3.17 (FMT0), U$3.19 (MODE0), U$3.20 (MODE1), U$4.1 (VDD), U$5.16 (VCC), U$6.16 (VCC)
+7V: C18.+, IC2.3 (VO), IC4.3 (VIN), L1.1, SV1.4
+12V: D2.A, SV3.1, SV3.2
A5V: C3.+, C6.1, C8.1, C20.1, IC3.2 (VOUT), JMP1.3, R4.2, U$3.5 (VCC)
ADR/FAULT: SV4.1
AD_BCK: U$3.11 (BCK), U$5.11 (2B2)
AD_DOUT: U$3.12 (DOUT), U$6.11 (2B2)
AD_LRCK: U$3.10 (LRCK), U$6.5 (1B2)
AGND: C3.-, C4.-, C6.2, C8.2, C10.2, C11.2, C12.2, C13.2, C20.2, IC3.1 (GND), R1.1, R2.1, SJ1.1, SJ2.1, U$3.6 (AGND), XL0.1, XL0.1@1 (1), XL0.1@2 (1), XR0.1, XR0.1@1 (1), XR0.1@2 (1)
BCLK_EX1: EXT1.6, U$5.12 (2B3)
BCLK_EX2: EXT2.6, U$5.13 (2B4)
CH_STATUS: U$2.15 (COUT)
DOUT_EX1: EXT1.4, U$6.12 (2B3)
DOUT_EX2: EXT2.4, U$6.13 (2B4)
ERNIE: D1.A, X3.2
ERROR: R15.2, U$2.27 (ERROR), U$2.28 (CKSEL), U$4.15 (GP5)
FSOUT0: R14.2, U$2.2 (FSOUT0), U$4.14 (GP4)
FSOUT1: R13.2, U$2.3 (FSOUT1), U$4.13 (GP3)
GND: C5.2, C7.2, C9.2, C14.2, C15.2, C16.1, C17.1, C18.-, C19.-, C21.2, C23.-, C24.2, C26.2, C27.2, D3.A, EXT1.1, EXT1.3, EXT2.1, EXT2.3, FS1.C, FS2.C, IC1.5 (I), IC1.7 (GND), IC2.2 (GND), IC4.1 (GND), K2.8 (-), OX1.2 (GND@2), OX1.4 (GND), OX1.5 (GND@5), OX1.6 (GND@6), POWER0.C, Q4.2 (GND), R3.2, R6.2, R18.1, R19.1, R20.2, R22.1, R23.1, RX_ERROR0.C, SJ1.2, SJ2.2, SPDIF0.1, SPDIF0.1@1 (1), SPDIF0.1@2 (1), SRCUNLOCK0.C, SV1.1, SV1.5, SV3.7, SV3.8, SV4.6, SV4.8, SV4.10, SV4.12, SV4.14, SV4.16, SV4.18, SV4.20, TVS0.A, U$1.1 (LGRP), U$1.8 (GND@8), U$1.11 (IFMT1), U$1.12 (IFMT2), U$1.16 (OWL1), U$1.17 (OWL0), U$1.18 (OFMT1), U$1.20 (TDMI), U$1.21 (GND@21), U$1.28 (MODE2), U$2.6 (DGND), U$2.13 (PSCK0), U$2.14 (PSCK1), U$2.19 (RSV), U$2.23 (AGND), U$3.8 (BYPAS), U$3.13 (DGND), U$3.16 (OSR), U$3.18 (FMT1), U$4.20 (GND), U$5.1 (/1OE)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
GND/NC: Q4.1 (GND/NC)
GP6: EXT1.2
GP7: EXT2.2, U$4.12 (GP2)
HAS_EMPH: U$2.17 (EMPH)
IS_AUDIO: U$2.1 (AUDIO)
LRCK_EX1: EXT1.5, U$6.4 (1B3)
LRCK_EX2: EXT2.5, U$6.3 (1B4)
LRCLK: R9.1, SV4.13
MCLK: Q4.3 (OUT), U$1.2 (RCKI), U$2.8 (XTI), U$3.15 (SCKI)
unnamed: C1.2, C1.3, XL0.2
unnamed: C2.2, C2.3, XR0.2
unnamed: C1.1, R1.2, U$3.1 (VIN_L)
unnamed: C2.1, R2.2, U$3.2 (VIN_R)
unnamed: C4.+, IC3.3 (VIN), L1.2
unnamed: JMP1.2, L3.1
unnamed: C22.2, R8.1
unnamed: K2.6, R8.2
unnamed: C14.1, C15.1, L2.2, U$2.24 (VCC)
unnamed: C16.2, R5.1, U$2.22 (FILT)
unnamed: C17.2, R5.2
unnamed: C22.1, U$2.20 (RXIN)
unnamed: C23.+, FUSE0.2, IC2.1 (VI), TVS0.C
unnamed: R7.2, U$4.6 (RESET)
unnamed: R11.2, U$1.23 (SDOUT)
unnamed: R10.2, U$1.25 (BCKO)
unnamed: R9.2, U$1.24 (LRCKO)
unnamed: C24.1, L3.2, OX1.3 (VCC), U$7.3 (VCC)
unnamed: IC1.1 (I), IC1.4 (O), R17.2, R18.2
unnamed: C25.1, R3.1, SPDIF0.2
unnamed: C25.2, IC1.3 (I), R17.1
unnamed: K2.5 (S), OX1.1 (OUT), U$7.1 (OUT)
unnamed: IC1.2 (O), K2.7 (O)
unnamed: D3.C, IC1.8 (O), IC1.10 (O), IC1.12 (O), K2.1 (+)
unnamed: POWER0.A, R12.1
unnamed: FS1.A, R13.1
unnamed: FS2.A, R14.1
unnamed: R15.1, RX_ERROR0.A
unnamed: R16.1, SRCUNLOCK0.A
unnamed: R19.2, SRC_BYPASS0.1, U$1.9 (BYPAS)
unnamed: R20.1, R21.2, U$4.5 (ADDR)
RELAIS: IC1.9 (I), IC1.11 (I), IC1.13 (I), R6.1, U$4.17 (GP7)
RESET: SV4.3, U$1.13 (/RST), U$2.21 (RST)
RX_BCK: U$2.11 (BCKO), U$5.10 (2B1)
RX_DOUT: U$2.12 (DOUT), U$6.10 (2B1)
RX_LRCK: U$2.10 (LRCKO), U$6.6 (1B1)
RX_SCK: U$2.4 (SCKO), U$5.6 (1B1)
SCL: SV1.2, SV4.17, U$4.3 (SCL)
SCLK: R10.1, SV4.11
SCLK_EX1: EXT1.7, U$5.4 (1B3)
SCLK_EX2: EXT2.7, U$5.3 (1B4)
SDA: SV1.3, SV4.15, U$4.4 (SDA)
SDIN: R11.1, SV4.7
SDOUT: SV4.9
SEL_A: R22.2, U$4.8 (GP0), U$5.14 (S0), U$6.14 (S0)
SEL_B: R23.2, U$4.9 (GP1), U$5.2 (S1), U$6.2 (S1)
SRC_LOCK: R16.2, U$1.14 (MUTE), U$1.15 (/RDY), U$4.16 (GP6)
SW_BCK: U$1.5 (BCKI), U$5.9 (2A)
SW_DOUT: U$1.4 (SDIN), U$6.9 (2A)
SW_LRCK: U$1.6 (LRCKI), U$6.7 (1A)
SW_SCLK: U$5.7 (1A)
USER_DATA: U$2.16 (UOUT)
VIN2: D1.C, D2.C, FUSE0.1
VREF1: C10.1, C11.1, U$3.3 (VREF1)
VREF2: C12.1, C13.1, R4.1, U$3.4 (VREF2)

Notes on the sheet:
CONV
SPDIF
Converter: CS8421 SRC4190?billiger SRC419[23]?Highend~{}
adr=0x40 (8bit)
https://www.conrad.de/de/p/cliff-lwl-steckverbinder-fcr684205r-toslink-empfaenger-457611.html
Digital für alle
FROM TAS58xx
I2C mcp23009 MAX7329? mcp4728
ohne ext CLK, kein FS
PDN
output master 96kHz
Inputs: Analog(PCM1802/AD1871) SPDIF( DIR9001,CS8416), 2xI2S(BT,USB,PI,ESP32)
Bypass Switch
INPUT SEL
EXT2
f=1/(2pi*R*C) = 7Hz
Power Options: * Header provides 12V+ (can be 9-24V fom AMP) * External 9-24V IC2 does StepDown to 7V and supplies the 2 linear regulators.
SlaveIn, MasterOut In i2s Out i2s 24bit 256fs
Switch: CD4052B SN3257 TS3A44159 TS5A3357 ADAU1701?~{}
Analog für ADC
screw terminal
(MCLK)
Add Sys Clock 2-50MHz
CKSEL=0 > recover CLK used 24.576-MHz clock on the XTI pin FMT01 = H > I2S format RESET? PSCK = L > 128fs, max 6.144MHz Wenn alle Slav'n kann man umschalter sparen ~{}

Board: 2 copper layers, 100.4 x 80.0 mm, 94 parts (2 on the bottom side), 74 nets.

Other parts of the board:
H1, H2, H3, H4: MOUNT-HOLE3.2; 3,2_237

## KiCad design PCB-KiCad/AMP2.kicad_pcb

Parts:
C1, C2, C3, C4: 220n; C1206; MOUSER 80-C1206C224K5R7210
C5, C6, C7, C8: 680n; C1206; MOUSER 810-C3216X7R1H684K
C9, C10: 1u; C0603; MOUSER 81-GRT188R61H105KE3D
C11, C13, C16, C20, C22: .1u; C0603; MOUSER 80-C1206C104K5R7210
C12: 10u; C1210; MOUSER 187-CL32A106KLULNNE
C14, C15, C17, C18, C19, C21: 220u; 150CLZ-1010; MOUSER 667-EEE-FC1V331AP 667-35SVPK330M
D1: SCHOTTKY-DIODESMC; SMC; MOUSER 621-B540C-F
FAULT----0: LEDSMT1206; 1206; MOUSER 645-599-0220-007F
H1, H2, H3, H4: MOUNT-HOLE3.2; 3,2
IC1: LD117A?S; SOT223; MOUSER 621-AZ1117CH2-33TRG1
IC2: R-78E-0.5; TO220V; MOUSER 919-R-78E5.0-0.5
IC3: TL770D; SO08; MOUSER 595-TL7705AIDR
L1, L2, L3, L4: 10uH; DR125; MOUSER 652-SRU1048-220Y 652-SRU1063A-220Y 652-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
L6: Fuse; L5650M; MOUSER 650-ASMDC300F/24-2
OUT-L0: MKDSN1,5/2-5,08; MKDSN1,5_2-5,08
OUT-R0: MKDSN1,5/2-5,08; MKDSN1,5_2-5,08
PWR-----0: LEDSMT1206; 1206; MOUSER 645-599-0220-007F
R1, R2: 2.2k; R0603; MOUSER 667-ERJ-3GEYJ222V
R3, R4, R6: 10k; R0603; MOUSER 667-ERJ-3EKF1002V
R5: 4.7k; R0603; MOUSER 667-ERJ-U03J472V
R7, R8, R9: 47; R0603; MOUSER 667-ERJ-3EKF1002V
SJ2: SJ
SV3: FE08-1; FE08
SV4: FE10-2
TVS0: 26Vbi; SMC; MOUSER 710-824551241
U$1: TAS5805M; TSSOP28; MOUSER 595-TAS5805MPWP
X3: MKDSN1,5/2-5,08; MKDSN1,5_2-5,08

Connections:
+3V3: C11.2, C12.2, IC1.4 (OUT), PWR-----0.C, R2.2, R5.2, R6.2, SV3.5, SV3.6, U$1.2 (DVDD); also elsewhere on the board
+5V: IC1.3 (IN), IC2.3 (VO), IC3.8 (+VS), SJ2.1, SV3.3, SV3.4
+12V: C13.2, C14.+, C15.+, C16.2, C17.+, C18.+, C19.+, C21.+, IC2.1 (VI), L6.2, SV3.1, SV3.2, TVS0.C, U$1.15 (PVDD@1), U$1.16 (PVDD@2), U$1.27 (PVDD@4), U$1.28 (PVDD@3)
ADR/FAULT: FAULT----0.A, R5.1, SV4.1, U$1.3 (ADR/FAULT); also elsewhere on the board
GND: C5.2, C6.2, C7.2, C8.2, C9.1, C10.1, C11.1, C12.1, C13.1, C14.-, C15.-, C16.1, C17.-, C18.-, C19.-, C20.1, C21.-, C22.1, IC1.1 (ADJ), IC2.2 (GND), IC3.4 (GND), R1.1, R4.1, SV3.7, SV3.8, SV4.6, SV4.8, SV4.10, SV4.12, SV4.14, SV4.16, SV4.18, SV4.20, TVS0.A, U$1.1 (DGND@1), U$1.5 (DGND@2), U$1.14 (AGND), U$1.19 (PGND@1), U$1.24 (PGND@2), U$1.EXP (PAD), X3.1
LRCLK: R7.2, SV4.13
unnamed: C5.1, L1.2, OUT-L0.1
unnamed: C1.2, L1.1, U$1.26 (OUT_A+)
unnamed: C2.2, L2.1, U$1.23 (OUT_A-)
unnamed: C3.2, L3.1, U$1.17 (OUT_B+)
unnamed: C4.2, L4.1, U$1.20 (OUT_B-)
unnamed: C1.1, U$1.25 (BST_A+)
unnamed: C2.1, U$1.22 (BST_A-)
unnamed: C3.1, U$1.18 (BST_B+)
unnamed: C4.1, U$1.21 (BST_B-)
unnamed: C6.1, L2.2, OUT-L0.2
unnamed: C7.1, L3.2, OUT-R0.2
unnamed: C8.1, L4.2, OUT-R0.1
unnamed 18: PWR-----0.A, R1.2; also elsewhere on the board
unnamed: SJ2.2, SV4.5
unnamed: C10.2, U$1.4 (VR_DIG)
unnamed: C9.2, U$1.13 (AVDD)
unnamed 22: FAULT----0.C, R2.1; also elsewhere on the board
unnamed: IC3.7 (SENSE), R3.1
unnamed: IC3.6 (RESET), R4.2
unnamed: C20.2, IC3.1 (REF)
unnamed: C22.2, IC3.3 (CT)
unnamed: R7.1, U$1.6 (LRCLK)
unnamed: R8.1, U$1.7 (SCLK)
unnamed: R9.1, U$1.8 (SDIN)
PDN: IC3.5 (~RESET), R6.1, U$1.12 (PDN)
RESIN: IC3.2 (~RESIN), SV4.3
SCL: SV4.17, U$1.11 (SCL)
SCLK: R8.2, SV4.11
SDA: SV4.15, U$1.10 (SDA)
SDIN: R9.2, SV4.7
SDOUT: SV4.9, U$1.9 (SDOUT)
VIN: D1.A, R3.2, X3.2
VIN2: D1.C, L6.1

Notes on the sheet:
wie freedsp ?
the amplified right signal is presented on differential output pair shown as OUT_B+ and OUT_B-.
+12V is actually the fused input voltage ~{} 9-25V
power off detection
trigger voltage adjust 10k > ~9V
(MCLK)
(acording datasheet 9.4.2.1 page 34)
R5 for DevAdr 4.7k 15k 47k 120k
The amplified left signal is presented on differential output pair shown as OUT_A+ and OUT_A-,
delay>>>
Datasheet suggests 10uH for 4ohm loads 22uH for 8ohm loads.
Absolut max VIN = 28V (limited by R-78E-0.5 regulator)

Board: 2 copper layers, 100.4 x 80.0 mm, 54 parts (1 on the bottom side), 39 nets.

Other parts of the board:
FAULT----: 1206_259
PWR----: 1206_259

Their connections:
+3V3: PWR----.C; also elsewhere on the board
ADR/FAULT: FAULT----.A; also elsewhere on the board
unnamed 18: PWR----.A; also elsewhere on the board
unnamed 22: FAULT----.C; also elsewhere on the board

## Commit log

2019-11-18 Added Terminals...
2019-11-18 Added Terminals 2...
2019-11-18 Removing backup files..
2019-11-19 longer todo list :(
2019-11-19 gitignore
2020-04-10 First success reports.
2020-04-19 some fixes..
2020-04-29 Removed Pi header, added power filter.
2020-04-29 Added License
2020-05-05 rev2..
2020-08-26 ci: add Azure Static Web Apps workflow file on-behalf-of: @Azure opensource@microsoft.com
2021-06-18 Started IO Board.
2021-06-19 Getting somewhere.
2021-07-06 Added Ext Headers, TORX, ... not complete yet.
2021-07-06 gitignore..
2021-07-12 Autorouted and Manual Layout
2021-07-14 Routed.
2021-07-15 Switched to SRC4192
2021-07-15 Tuning..
2021-07-16 603 packs and some other stuff. Changed MCLK to 24.576 needed by DIR9001 for FS detection.
2021-07-24 Changed switching chipies to SN74CBT3253.
2021-07-25 Fixed Power Input, added fuses and TCS diodes.
2021-07-25 added mouser nr's
2021-07-25 Added brown out, 3D models...
2021-07-25 Eagle is a mess. Any capable developers left @ ADSK ?
2021-07-25 Added pull up for mcp reset line.
2021-07-25 Changed back to 1206 LEDs, in stock!
2021-07-25 LED 1206.
2021-07-25 BOM...
2021-07-27 Cosmetics..
2021-07-31 Updated readme, renamed PCB-Eagle to PCB-AMP2
2021-07-31 Fixed V-detect sense input.
2021-07-31 Minor fixes.
2021-09-02 Beauty Fixes
2021-10-26 BOM update/optimized
2021-10-26 BOM optimized... more attributes
2021-10-27 Added some mouser numbers
2021-10-31 Delete azure-static-web-apps-delightful-water-0ec8a6803.yml
    No deploy in use here
2021-11-04 Quick fixes to RC1
2021-12-07 Some RC1 bugs fixed.
2021-12-08 More fixes on AMP2-IO.
2024-10-29 KiCad freedomination
