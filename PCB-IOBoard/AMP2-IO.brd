File: PCB-IOBoard/AMP2-IO.brd (EAGLE design)
At the start: 100.4 x 80 mm, 86 parts, among them IC1 7404D, IC2 R-78E9.0-0.5, IC3 REG1117, IC4 REG1117, K2 GN210S03, Q4 24.576, X3 MKDSN1,5/2-5,08

Commit message: Fixed Power Input, added fuses and TCS diodes.
Parts:
- added L4: fuse, rcl:L4532M
- added TVS: 26Vbi, diode:SMC
- moved D1 14.2 mm to (43.9, 5.84)
- moved D2 14.2 mm to (43.9, 11.9)
Connections:
- new net N$20: C23.+, IC2.1, L4.2, TVS.C
- net +7V: now also SV1.4
- net GND: now also SV1.5, TVS.A
- net VIN2: now also L4.1; no longer C23.+, IC2.1
Routing:
- net N$20: track 0.00 -> 32.5 mm
- net +7V: track 105.1 -> 123.4 mm
- net +12V: track 43.5 -> 26.8 mm
- net VIN2: track 26.5 -> 12.5 mm
- net N$5: track 41.3 -> 38.2 mm
- net ERNIE: track 11.9 -> 10.1 mm
- net GND: vias 192 -> 225
- net A5V: vias 13 -> 18
Other:
- board text added: "7V+"

Commit message: Eagle is a mess. Any capable developers left @ ADSK ?
Parts:
- IC1: value 7404D -> 7404TS; device 74xx-eu:SO14 -> 74xx-eu:TSSOP14
- IC2: value R-78E9.0-0.5 -> R-78E6.5-0.5
- L4: value fuse -> Fuse
- moved C26 2.75 mm to (21.6, 55.1), turned to 90 degrees
- moved R6 2.74 mm to (13.7, 54.9)
Routing:
- net RELAIS: track 45.9 -> 41.8 mm
- net N$20: track 32.5 -> 35.6 mm
- net +3V3: track 176.7 -> 179.3 mm
- net N$35: track 28.1 -> 26.1 mm
- net GND: track 70.9 -> 72.6 mm
- net N$29: track 12.8 -> 11.1 mm
- net N$34: track 13.3 -> 14.8 mm

Commit message: Added pull up for mcp reset line.
Parts:
- added R7: 2.2k, rcl:R0603
- moved C23 2.34 mm to (68.3, 8.38)
- renumbered L4 to FUSE
Connections:
- new net N$21: R7.2, U$4.6
- net +3V3: now also R7.1
Routing:
- net N$21: track 0.00 -> 13.4 mm
- net N$20: track 35.6 -> 30.3 mm
- net SEL_B: track 25.0 -> 23.7 mm
- net GND: vias 225 -> 226
Other:
- board text added: "NC"
- board text removed: "GP6"

Commit message: Changed back to 1206 LEDs, in stock!
Parts:
- FS1, FS2, POWER, RX_ERROR, SRCLOCK: device led:CHIPLED_0805 -> led:1206
- turned FS1 to 90 degrees
- turned FS2 to 90 degrees
- turned POWER to 90 degrees
- turned RX_ERROR to 90 degrees
- turned SRCLOCK to 90 degrees
Routing:
- net ERROR: track 32.2 -> 33.6 mm

Commit message: Cosmetics..
Other:
- board text added: "9-25V"
- board text added: "DATA"
- board text added: "red"
- board text removed: "9-24V"
- board text removed: "DOUT"
Changed lines of the file:
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@@
 <wire x1="78.232" y1="6.858" x2="78.232" y2="4.318" width="0.1524" layer="25"/>
 <text x="75.692" y="5.588" size="1.778" layer="25" rot="R270">1</text>
-<text x="27.178" y="0.762" size="1.778" layer="25">9-24V</text>
+<text x="27.178" y="0.762" size="1.778" layer="25">9-25V</text>
 <text x="0.508" y="17.526" size="1.27" layer="25">SCL</text>
 <text x="0.508" y="20.066" size="1.27" layer="25">SDA</text>
@@
 <text x="0.508" y="32.766" size="1.27" layer="25">BCLK</text>
 <text x="0.508" y="35.306" size="1.27" layer="25">LRCK</text>
-<text x="0.254" y="37.846" size="1.27" layer="25">DOUT</text>
+<text x="0.254" y="37.846" size="1.27" layer="25">DATA</text>
 <text x="1.016" y="48.006" size="1.27" layer="25">3.3V</text>
 <text x="0.508" y="50.546" size="1.27" layer="25">SCLK</text>
 <text x="0.508" y="53.086" size="1.27" layer="25">BCLK</text>
 <text x="0.508" y="55.626" size="1.27" layer="25">LRCK</text>
-<text x="0.254" y="58.166" size="1.27" layer="25">DOUT</text>
+<text x="0.254" y="58.166" size="1.27" layer="25">DATA</text>
 <text x="0.762" y="66.04" size="1.27" layer="25">GND</text>
 <text x="0.762" y="45.72" size="1.27" layer="25">GND</text>
@@
 </polygon>
 <circle x="64.008" y="45.466" radius="0.359209375" width="0.254" layer="25"/>
+<wire x1="60.96" y1="24.13" x2="60.96" y2="19.05" width="0.1524" layer="25"/>
+<wire x1="55.118" y1="24.13" x2="55.118" y2="14.732" width="0.4064" layer="25"/>
+<text x="54.61" y="14.986" size="1.778" layer="25" rot="R90">red</text>
 </plain>
 <attributes>
@@
 </element>
 <element name="C3" library="rcl" library_urn="urn:adsk.eagle:library:334" package="CT6032" package3d_urn="urn:adsk.eagle:package:23305/2" value="10u" x="92.202" y="42.672" smashed="yes" rot="R270">
+<attribute name="MOUSER" value="80-T491C106K25AT7280" x="92.202" y="42.672" size="1.778" layer="27" rot="R270" display="off"/>
 <attribute name="NAME" x="94.43" y="43.644" size="1.27" layer="25" rot="R270"/>
 <attribute name="POPULARITY" value="2" x="92.202" y="42.672" size="1.778" layer="27" rot="R270" display="off"/>
@@
 </element>
 <element name="C4" library="rcl" library_urn="urn:adsk.eagle:library:334" package="CT6032" package3d_urn="urn:adsk.eagle:package:23305/2" value="10u" x="92.202" y="31.242" smashed="yes" rot="R90">
+<attribute name="MOUSER" value="80-T491C106K25AT7280" x="92.202" y="31.242" size="1.778" layer="27" rot="R90" display="off"/>
 <attribute name="NAME" x="95.562" y="31.032" size="1.27" layer="25" rot="R90"/>
 <attribute name="POPULARITY" value="2" x="92.202" y="31.242" size="1.778" layer="27" rot="R90" display="off"/>
@@
 </element>
 <element name="C8" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C1210K" package3d_urn="urn:adsk.eagle:package:23683/2" value="10u" x="67.564" y="60.452" smashed="yes" rot="R180">
+<attribute name="MOUSER" value="81-GCM32DL81A106KA7L" x="67.564" y="60.452" size="1.778" layer="27" rot="R180" display="off"/>
 <attribute name="NAME" x="68.656" y="63.22" size="1.016" layer="25" rot="R180"/>
 <attribute name="POPULARITY" value="0" x="67.564" y="60.452" size="1.778" layer="27" rot="R180" display="off"/>
@@
 </element>
 <element name="C9" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C1210K" package3d_urn="urn:adsk.eagle:package:23683/2" value="10u" x="71.882" y="39.116" smashed="yes" rot="R180">
+<attribute name="MOUSER" value="81-GCM32DL81A106KA7L" x="71.882" y="39.116" size="1.778" layer="27" rot="R180" display="off"/>
 <attribute name="NAME" x="76.022" y="40.106" size="1.016" layer="25" rot="R180"/>
 <attribute name="POPULARITY" value="0" x="71.882" y="39.116" size="1.778" layer="27" rot="R180" display="off"/>
@@
 </element>
 <element name="C12" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C1210K" package3d_urn="urn:adsk.eagle:package:23683/2" value="10u" x="72.898" y="60.452" smashed="yes">
+<attribute name="MOUSER" value="81-GCM32DL81A106KA7L" x="72.898" y="60.452" size="1.778" layer="27" display="off"/>
 <attribute name="NAME" x="71.298" y="62.002" size="1.016" layer="25"/>
 <attribute name="POPULARITY" value="0" x="72.898" y="60.452" size="1.778" layer="27" display="off"/>
@@
 </element>
 <element name="C14" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C1210K" package3d_urn="urn:adsk.eagle:package:23683/2" value="10u" x="42.164" y="60.706" smashed="yes">
+<attribute name="MOUSER" value="81-GCM32DL81A106KA7L" x="42.164" y="60.706" size="1.778" layer="27" display="off"/>
 <attribute name="NAME" x="40.564" y="62.256" size="1.016" layer="25"/>
 <attribute name="POPULARITY" value="0" x="42.164" y="60.706" size="1.778" layer="27" display="off"/>
@@
 </element>
 <element name="C18" library="rcl" library_urn="urn:adsk.eagle:library:334" package="CT6032" package3d_urn="urn:adsk.eagle:package:23305/2" value="10u" x="13.97" y="8.89" smashed="yes" rot="R270">
+<attribute name="MOUSER" value="80-T491C106K25AT7280" x="13.97" y="8.89" size="1.778" layer="27" rot="R270" display="off"/>
 <attribute name="NAME" x="16.214" y="12.672" size="1.27" layer="25" rot="R270"/>
 <attribute name="POPULARITY" value="2" x="13.97" y="8.89" size="1.778" layer="27" rot="R270" display="off"/>
@@
 </element>
 <element name="C19" library="rcl" library_urn="urn:adsk.eagle:library:334" package="CT6032" package3d_urn="urn:adsk.eagle:package:23305/2" value="10u" x="13.97" y="18.542" smashed="yes" rot="R270">
+<attribute name="MOUSER" value="80-T491C106K25AT7280" x="13.97" y="18.542" size="1.778" layer="27" rot="R270" display="off"/>
 <attribute name="NAME" x="16.214" y="16.482" size="1.27" layer="25" rot="R270"/>
 <attribute name="POPULARITY" value="2" x="13.97" y="18.542" size="1.778" layer="27" rot="R270" display="off"/>
@@
 </element>
 <element name="IC1" library="74xx-eu" package="TSSOP14" package3d_urn="urn:adsk.eagle:package:2019/3" value="7404TS" x="17.526" y="56.642" smashed="yes" rot="R180">
-<attribute name="MOUSER" value="595-SN74HC04DRG4 " x="17.526" y="56.642" size="1.778" layer="27" rot="R180" display="off"/>
+<attribute name="MOUSER" value="595-SN74HC04APWR" x="17.526" y="56.642" size="1.778" layer="27" rot="R180" display="off"/>
 <attribute name="VALUE" x="16.891" y="58.166" size="1.27" layer="25" ratio="10" rot="R180"/>
 </element>
@@
 <element name="K2" library="relay" library_urn="urn:adsk.eagle:library:339" package="GN-S" package3d_urn="urn:adsk.eagle:package:24396/1" value="GN210S03" x="30.988" y="58.42" smashed="yes">
 <attribute name="MF" value="" x="30.988" y="58.42" size="1.778" layer="27" display="off"/>
+<attribute name="MOUSER" value="769-AGN210S03Z" x="30.988" y="58.42" size="1.778" layer="27" display="off"/>
 <attribute name="MPN" value="AGN210S03" x="30.988" y="58.42" size="1.778" layer="27" display="off"/>
 <attribute name="NAME" x="29.337" y="57.15" size="1.27" layer="25" rot="R90"/>
@@
 </element>
 <element name="U$5" library="AMP2-ICs" package="TSSOP16-PW" package3d_urn="urn:adsk.eagle:package:4949/1" value="SN74CBT3253" x="44.958" y="41.656" smashed="yes" rot="R270">
+<attribute name="MOUSER" value="595-SN74CBT3253CPW" x="44.958" y="41.656" size="1.778" layer="27" rot="R270" display="off"/>
 <attribute name="VALUE" x="41.238" y="31.04" size="1.27" layer="25" ratio="10" rot="R90"/>
 </element>
@@
 <element name="TVS" library="diode" library_urn="urn:adsk.eagle:library:210" package="SMC" package3d_urn="urn:adsk.eagle:package:43425/2" value="26Vbi" x="59.69" y="8.89" smashed="yes" rot="R90">
 <attribute name="MOUSER" value="710-824551241" x="59.69" y="8.89" size="1.778" layer="27" rot="R90" display="off"/>
-<attribute name="NAME" x="61.595" y="4.191" size="1.27" layer="25" rot="R180"/>
+<attribute name="NAME" x="61.341" y="3.429" size="1.27" layer="25" rot="R180"/>
 <attribute name="POPULARITY" value="1" x="59.69" y="8.89" size="2.54" layer="27" rot="R90" display="off"/>
-<attribute name="VALUE" x="62.357" y="2.667" size="1.27" layer="27" rot="R180"/>
+<attribute name="VALUE" x="61.849" y="1.905" size="1.27" layer="27" rot="R180"/>
 </element>
 <element name="R7" library="rcl" library_urn="urn:adsk.eagle:library:334" package="R0603" package3d_urn="urn:adsk.eagle:package:23555/3" value="2.2k" x="28.956" y="28.956" smashed="yes">
